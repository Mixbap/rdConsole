# Keil uVision project rdConsole.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rdConsole +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User\src;.\User\inc;.\MELT_LCD_lib
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./User/src/: ini.c it.c main.c console.c lcd.c
  group MELT_LCD_lib
    ./MELT_LCD_lib/: mlt_lcd.c
software components: CMSIS:CORE 4.3.0, Device:Startup_MDR1986BE9x 1.3.1, Drivers:DAC 1.3.1, Drivers:DMA 1.3.1, Drivers:EEMPROM 1.3.1, Drivers:PORT 1.3.1, Drivers:RST_CLK 1.3.1, Drivers:TIMER 1.3.1, Drivers:UART 1.3.1
